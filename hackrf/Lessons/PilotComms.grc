<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1040e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192e3</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>variable_text_box_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value></value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
<param><key>rate</key><value>625e-6</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>audio_decim</key><value>1</value></param>
<param><key>audio_pass</key><value>6000</value></param>
<param><key>audio_stop</key><value>8000</value></param>
<param><key>chan_rate</key><value>48e3</value></param>
</block>
<block>
<key>analog_pll_carriertracking_cc</key>
<param><key>id</key><value>analog_pll_carriertracking_cc_0</value></param>
<param><key>w</key><value>50e-3</value></param>
<param><key>max_freq</key><value>65.4e-3</value></param>
<param><key>min_freq</key><value>-65.4e-3</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>300e-3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>6e3</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>2e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>center_freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>analog_pll_carriertracking_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_pll_carriertracking_cc_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
